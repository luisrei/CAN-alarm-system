# Keil uVision project Master.uvprojx, settings and files
target Master (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.pdsc
  cpu: CPUTYPE("Cortex-M3")
  output: Master
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DTARGET_LPCTarget -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DMBED_BUILD_TIMESTAMP=1495904659.89 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; mbed; mbed/LPC1768; mbed/LPC1768/ARM; C12832; PowerControl; PowerControl/PowerControl; PinDetect;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/LPC1768/ARM/LPC1768.sct
  group C12832
    C12832/: C12832.cpp C12832.h GraphicsDisplay.cpp GraphicsDisplay.h Small_7.h TextDisplay.cpp TextDisplay.h
  group Master
    ./: main.cpp mbed_config.h
  group mbed
    mbed/: AnalogIn.h AnalogOut.h Base.h BusIn.h BusInOut.h BusOut.h CAN.h can_helper.h device.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h error.h Ethernet.h FileHandle.h FileLike.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h LocalFileSystem.h mbed.h mbed_interface.h PeripheralNames.h PinNames.h platform.h PortIn.h PortInOut.h PortNames.h PortOut.h PwmOut.h rpc.h rtc_time.h Serial.h SerialHalfDuplex.h SPI.h SPIHalfDuplex.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h us_ticker_api.h wait_api.h
    mbed/LPC1768/ARM/: capi.ar cmsis_nvic.o core_cm3.o mbed.ar startup_LPC17xx.o sys.o system_LPC17xx.o
    mbed/LPC1768/: cmsis.h cmsis_nvic.h core_cm3.h core_cmFunc.h core_cmInstr.h LPC17xx.h system_LPC17xx.h
  group PinDetect
    PinDetect/: ChangeLog.h example.h PinDetect.h
  group PowerControl
    PowerControl/PowerControl/: EthernetPowerControl.cpp EthernetPowerControl.h PowerControl.h
